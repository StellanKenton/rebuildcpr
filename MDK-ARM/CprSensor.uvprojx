# Keil uVision project CprSensor.uvprojx, settings and files
target CprSensor (5060960::V5.06 update 7 (build 960)::.\ACC5)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: CprSensor +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE,DRVGPIO_LOG_SUPPORT=0,DRVGPIO_CONSOLE_SUPPORT=1
  c include: ..;../Core/Inc;../User;../User/manager;../User/system;../User/port;../USB_DEVICE/App;../USB_DEVICE/Target;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../rep/comm/frameparser;../rep/driver/drviic;../rep/driver/drvspi;../rep/driver/drvuart;../rep/driver/drvgpio;../rep/driver/drvadc;../rep/driver/drvusb;../rep/driver/drvanlogiic;../rep/module/lis2hh12;../rep/module/mpu6050;../rep/module/w25qxxx;../rep/module/pca9535;../rep/module/tm1651;../rep/module/wt2003hx;../rep/module/lsm6;../rep/sys/rtos;../rep/sys/system;../rep/tools/ringbuffer;../rep/tools/jsonparser;../rep/tools/md5;../rep/tools/aes;../SEGGER
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c dma.c i2c.c iwdg.c rtc.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_ll_usb.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group ThirdParty/SEGGER
    ../SEGGER/: SEGGER_RTT.c
  group App
    ../User/manager/power/: power.c
    ../User/manager/selfcheck/: selfcheck.c selfcheck_fault.c
    ../User/manager/memory/: memory.c memory_debug.c
    ../rep/service/vfs/: vfs.c vfs_littlefs.c vfs_debug.c
    ../rep/lib/littlefs/: lfs.c lfs_util.c
    ../User/manager/update/: update.c
    ../User/manager/cpralg/: cpralgmgr.c cpr_alg.lib
    ../User/manager/audio/: audio.c
    ../User/manager/iotmanager/: cprsensor_protocol.c iotmanager.c protcolmgr.c protcolmgr_debug.c
    ../User/manager/wireless/: wireless.c wireless_ble.c wireless_wifi.c
    ../rep/module/fc41d/: fc41d.c fc41d_ctrl.c fc41d_data.c
    ../rep/module/ec800m/: ec800m.c ec800m_http.c ec800m_mqtt.c
    ../rep/module/esp32c5/: esp32c5.c esp32c5_ctrl.c esp32c5_data.c esp32c5_ble.c esp32c5_http.c esp32c5_mqtt.c esp32c5_wifi.c
    ../rep/module/wt2003hx/: wt2003hx.c
    ../rep/comm/flowparser/: flowparser.c flowparser_stream.c
    ../User/system/: sysmgr.c systask.c system_debug.c
    ../rep/sys/system/: system.c
  group Drv
    ../rep/driver/drvadc/: drvadc.c
    ../rep/driver/drvanlogiic/: drvanlogiic.c
    ../rep/driver/drvgpio/: drvgpio.c
    ../rep/driver/drviic/: drviic.c
    ../rep/driver/drvspi/: drvspi.c
    ../rep/driver/drvuart/: drvuart.c
    ../rep/driver/drvusb/: drvusb.c
    ../rep/driver/drvmcuflash/: drvmcuflash.c
    ../rep/module/gd25qxxx/: gd25qxxx.c
    ../rep/module/w25qxxx/: w25qxxx.c
    ../rep/module/sdcard/: sdcard.c
    ../rep/module/mpu6050/: mpu6050.c
    ../rep/module/lis2hh12/: lis2hh12.c
    ../rep/module/pca9535/: pca9535.c
    ../rep/module/tm1651/: tm1651.c
  group Bsp
    ../User/bsp/: bsp_rtt.c bspanlogiic.c bspgpio.c bspiic.c bspspi.c bspuart.c bspusb.c
  group Lib
    ../rep/tools/ringbuffer/: ringbuffer.c
    ../rep/tools/jsonparser/: jsonparser.c
    ../rep/tools/md5/: md5.c
    ../rep/tools/aes/: aes.c
    ../rep/comm/frameparser/: framepareser.c
    ../rep/service/log/: console.c log.c
    ../rep/service/rtos/: rtos.c
  group Port
    ../User/port/: drvadc_port.c drvgpio_port.c drviic_port.c drvspi_port.c drvuart_port.c fc41dport.c frameparser_port.c lis2hh12_port.c mpu6050_port.c drvusb_port.c drvmcuflash_port.c log_port.c ringbuffer_port.c pca9535_port.c rtos_port.c tm1651_port.c wt2003hx_port.c drvanlogiic_port.c gd25qxxx_port.c w25qxxx_port.c sdcard_port.c ec800m_port.c esp32c5_port.c vfs_littlefs_port.c
  group Debug
    ../rep/driver/drvadc/: drvadc_debug.c
    ../rep/driver/drvanlogiic/: drvanlogiic_debug.c
    ../rep/driver/drvgpio/: drvgpio_debug.c
    ../rep/driver/drviic/: drviic_debug.c
    ../rep/driver/drvspi/: drvspi_debug.c
    ../rep/driver/drvuart/: drvuart_debug.c
software components: CMSIS:CORE 4.3.0
